# IAR project stm32++_IAR_9.ewp, settings and files
configuration stm32f207 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F2XX
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F2xx\Include; lib\STM32F207_StdPeriph_Driver\inc; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  postbuild: cmd /C start /D "doxygen" doxygen Doxyfile
  ILINK.IlinkOutputFile: stm32++_IAR_9.out
configuration stm32f373xB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F373xB ST STM32F373xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F37X
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F37x\Include; lib\STM32F373_StdPeriph_Driver\inc; src
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f373xB_no-exceptions_no-rtti (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F373xB ST STM32F373xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F37X; NO_EXCEPTIONS; NO_RTTI
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f407zg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40XX
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F4xx\Include; lib\STM32F407_StdPeriph_Driver\inc; src
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f407vg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: as above
  postbuild: cmd /C rem start /D "doxygen" doxygen Doxyfile
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f405rg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F405xx
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f405rg_no-exceptions_no-rtti (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F405xx; NO_EXCEPTIONS; NO_RTTI
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f427ii (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F427II ST STM32F427II
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427_437xx
  ICCARM.CCIncludePath2: as above
configuration stm32f429zi (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f446 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446RC ST STM32F446RC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F446xx
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32l476rg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx
  ICCARM.CCIncludePath2: src
  postbuild: cmd /C rem start /D "doxygen" doxygen Doxyfile
  ILINK.IlinkOutputFile: stm32++.out
  group (top)
    src/: absoluteencoder.h adc.cpp adc.h analogservo.cpp analogservo.h as5040master.cpp as5040master.h button.cpp button.h buzzer.cpp buzzer.h can.cpp can.h can_old.cpp can_old.h cpuid.cpp cpuid.h dac.cpp dac.h dac37x.cpp dac37x.h dac4xx.h dma.h dma37x.cpp dma37x.h dma4xx.cpp dma4xx.h dma_l4.cpp dma_l4.h encoder.cpp encoder.h flash.h flash37x.cpp flash37x.h flash4xx.cpp flash4xx.h flashdrive.cpp flashdrive.h gpio.cpp gpio.h hardwaretimer.cpp hardwaretimer.h i2c.cpp i2c.h i2s.cpp i2s.h led.cpp led.h led7.cpp led7.h motorDC.cpp motorDC.h picontroller.cpp picontroller.h powermanager.cpp powermanager.h precisetimer.cpp precisetimer.h pwminput.cpp pwminput.h pwmout.cpp pwmout.h rcc.cpp rcc.h rgbled.cpp rgbled.h sdadc.cpp sdadc.h spi.cpp spi.h stm32.h stm32_conf.h usart.cpp usart.h
  group _doxygen
    doxygen/: Doxyfile mainpage.md
  group audio
    src/audio/: amicrophone.cpp amicrophone.h aspeaker.cpp aspeaker.h audiodev.cpp audiodev.h audioformat.h i2smicrophone.cpp i2smicrophone.h microphone.cpp microphone.h speaker.cpp speaker.h
  group core
    src/core/: application.cpp application.h bytearray.cpp bytearray.h closure.h closure_impl.h core.cpp core.h coreexception.h coretypes.h device.cpp device.h macros.h qdebug.cpp qdebug.h ringbuffer.h timer.cpp timer.h
  group device
    src/device/: ads1220.c ads1220.h adxl345.cpp adxl345.h as5047d.cpp as5047d.h bmx055.cpp bmx055.h drv8320.cpp drv8320.h eeprom24c.h ili9486.cpp ili9486.h mt6818.cpp mt6818.h mt6825.cpp mt6825.h mt6835.cpp mt6835.h xpt2046.cpp xpt2046.h
  group gfx
    src/gfx/: color.h display.cpp display.h font.cpp font.h fontdatabase.cpp fontdatabase.h fontinfo.h image.cpp image.h touchscreen.cpp touchscreen.h
  group gfx/gui
    src/gfx/gui/: abstractspinbox.cpp abstractspinbox.h flexlayout.h floatspinbox.cpp floatspinbox.h font_Tahoma_13.cpp gridlayout.h guiapplication.cpp guiapplication.h guitypes.h label.cpp label.h layout.h ledwidget.cpp ledwidget.h lineedit.cpp lineedit.h pagelayout.h pushbutton.cpp pushbutton.h spinbox.cpp spinbox.h widget.cpp widget.h widgets.h
  group objnet
    src/objnet/: canInterface.cpp canInterface.h genericonbinterface.cpp genericonbinterface.h objectinfo.cpp objectinfo.h objnetclasses.h objnetcommon.h objnetCommonNode.cpp objnetCommonNode.h objnetdevice.cpp objnetdevice.h objnetInterface.cpp objnetInterface.h objnetmaster.cpp objnetmaster.h objnetmsg.cpp objnetmsg.h objnetnode.cpp objnetnode.h objnetstorage.cpp objnetstorage.h onbvirtualinterface.cpp onbvirtualinterface.h radioonbinterface.cpp radioonbinterface.h uartonbinterface.cpp uartonbinterface.h usbhidonbinterface.cpp usbhidonbinterface.h
  group radio
    src/radio/: cc1200.cpp cc1200.h cc1200_const.h radiointerface.cpp radiointerface.h
  group serial
    src/serial/: esp8266.cpp esp8266.h serialframe.cpp serialframe.h serialinterface.h seriallink.cpp seriallink.h usbvcp.cpp usbvcp.h
  group usb
    src/usb/: usb.h usbcfg.cpp usbcfg.h usbconst.h usbdesc.cpp usbdesc.h usbdev.cpp usbdev.h usbdevdrv.cpp usbdevdrv.h usbep.cpp usbep.h usbif.cpp usbif.h usbifcol.cpp usbifcol.h usbnode.cpp usbnode.h usbreq.cpp usbreq.h
  group usb/otgDriver
    src/usb/otgDriver/: usb_bsp.h usb_conf.h usb_core.cpp usb_core.h usb_defines.h usb_regs.h
  group usb/usbAudio
    src/usb/usbAudio/: usbaudio.cpp usbaudio.h usbaudiodesc.h
  group usb/usbCdc
    src/usb/usbCdc/: usbcdc.cpp usbcdc.h
  group usb/usbHid
    src/usb/usbHid/: hiditem.h hidusage.h usbhid.cpp usbhid.h
  group usb/usbMsc
    src/usb/usbMsc/: mscbot.cpp mscbot.h scsi.cpp scsi.h scsiinterface.cpp scsiinterface.h usbmsc.cpp usbmsc.h
  group usb/usbVideo
    src/usb/usbVideo/: usbVideo.cpp usbvideo.h
